# Keil uVision project STC-2.25inch-76x284-LCD-ZJY225KP.uvproj, settings and files
target Sample (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC-LCD-ZJY225KP +hex
  group Source
    ./: main.c
